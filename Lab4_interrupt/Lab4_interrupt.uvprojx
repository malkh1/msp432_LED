# Keil uVision project Lab4_interrupt.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4_interrupt
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source Group 1
    ./: main.c led.h led.c
software components: CMSIS:CORE 5.5.0, Device:Startup 3.2.2
